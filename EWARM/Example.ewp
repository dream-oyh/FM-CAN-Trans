# IAR project Example.ewp, settings and files
configuration Example (ARM, debug)
  General.OGChipSelectEditMenu: FM33FG06XA FMSH FM33FG06XA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCDefines: FM33FG0XXA; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../Drivers/CMSIS/Inculde; ../Drivers/CMSIS/Device/FM/FM33xx/Include; ../Drivers/FM33FG0xxA_FL_Driver/Inc; ../MF-config/Inc; ../Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.hex
  ILINK.IlinkOutputFile: Example.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\FMSH\FM33FG06XA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/IAR
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33fg0xxa.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: can.c clock.c gpio.c iwdt.c key.c lptim16.c main.c rmu.c svd.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33fg0xxa.c
  group Drivers/FM33FG0xxA_FL_Driver
    ../Drivers/FM33FG0xxA_FL_Driver/Src/: fm33fg0xxa_fl.c fm33fg0xxa_fl_adc.c fm33fg0xxa_fl_aes.c fm33fg0xxa_fl_atim.c fm33fg0xxa_fl_bstim16.c fm33fg0xxa_fl_bstim32.c fm33fg0xxa_fl_can.c fm33fg0xxa_fl_canfd.c fm33fg0xxa_fl_clm.c fm33fg0xxa_fl_cmu.c fm33fg0xxa_fl_comp.c fm33fg0xxa_fl_crc.c fm33fg0xxa_fl_dac.c fm33fg0xxa_fl_dma.c fm33fg0xxa_fl_exti.c fm33fg0xxa_fl_flash.c fm33fg0xxa_fl_gpio.c fm33fg0xxa_fl_gptim.c fm33fg0xxa_fl_hdiv.c fm33fg0xxa_fl_i2c_master.c fm33fg0xxa_fl_i2c_smbus.c fm33fg0xxa_fl_iwdt.c fm33fg0xxa_fl_lptim16.c fm33fg0xxa_fl_lptim32.c fm33fg0xxa_fl_lpuart.c fm33fg0xxa_fl_pgl.c fm33fg0xxa_fl_pmu.c fm33fg0xxa_fl_rng.c fm33fg0xxa_fl_rtc.c fm33fg0xxa_fl_sent.c fm33fg0xxa_fl_spi.c fm33fg0xxa_fl_svd.c fm33fg0xxa_fl_tau.c fm33fg0xxa_fl_uart.c fm33fg0xxa_fl_wwdt.c
